# IAR project Backup of Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_ETH_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\port; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include\ipv4; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include\lwip; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\src\include; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\port\STM32\arch; ..\..\..\Utilities\Third_Party\lwip_v1.3.1\port\STM32
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group LwIP
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/core/: dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Utilities/Third_Party/lwip_v1.3.1/src/netif/: etharp.c
  group LwIP/port
    ../../../Utilities/Third_Party/lwip_v1.3.1/port/STM32/: ethernetif.c ethernetif.h
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group STM32F107_ETH_Driver
    ../../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../src/: common.c download.c flash.c flash_if.c httpserver.c main.c netconf.c spi.c stm32f107.c stm32f10x_it.c tftpserver.c ymodem.c
  group User/Header
    ../inc/: flash.h spi.h
