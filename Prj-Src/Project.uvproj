# Keil uVision project Project.uvproj, settings and files
target MCBSTM32C RTX (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Http_demo +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ./aa.bin ./obj/Http_demo.axf
  c flags: Optim=1
  c define: RTX_KERNEL,STM32F10X_CL,USE_STDPERIPH_DRIVER,STM3210C,
  c include: ..\Library;..\Library\MDK-Lib;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Prj-Src;.\inc;..\Library\STM32_ETH_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8009000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi system.cgi pg_footer.inc pg_header.inc aplication_set.cgi main_page.cgi
  group Source Files
    ./: HTTP_CGI.c main.c stm32f10x_it.c
    ./Web/: WEB.C
    ./src/: Device_Init.c Global.c adc_lxb.c log.c I2C.c spi.c Data_Init.c key.c data_m.c Usart.c Machine.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c startup_stm32f10x_cl.s
  group MDK-Library
    ../Library/MDK-Lib/: ETH_STM32x.c system_stm32f10x_cl.c
    ./: TCP_CM3.lib
  group Documentation
    ./: Abstract.txt
  group ST-Library
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c
    ../Library/STM32_ETH_Driver/src/: stm32_eth.c
